Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: bd73e2eb-d7c3-480c-ad70-b7bccc5ba98e, NumberOfSaves: 1]
File name: 0001
Time: 2024-08-27T16:10:26+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11886680_OE1_G7200SC_BW:21720016_OE1_11886680_G7200SC_BW, (2)
In: Default
Type - Material: z_Miele_Design_Glass Black, z_Miele_Design_BRWS, z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, Polypropylene, z_Miele_Design_Steel_Chrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 598 mm; Height: 845 mm; Depth: 600 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 21720016_OE1_11886680_G7200SC_BW; sets with these values: 2

# IfcDistributionPort, Port_357890_1
Description: Flow; FlowDirection: SOURCEANDSINK
